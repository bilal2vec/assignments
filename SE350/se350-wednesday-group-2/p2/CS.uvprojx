# Keil uVision project CS.uvprojx, settings and files
target CS SIM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CS
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: DEBUG_0 SIM_TARGET K_MSG_ENV AE_ENABLE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Doc
    ./doc/: README.txt
  group System Code
    ./src/: main_svc.c printf.c uart_polling.c
  group Kernel
    ./src/: HAL.c k_memory.c k_msg.c k_process.c k_rtx_init.c queue.c k_rtx.c k_timer.c
  group AE
    ./src/: ae.c ae_util.c ae_timer.c
  group AE-active
    ./src/: ae_proc211.c
  group AE-pub-inactive
    ./src/: ae_proc212.c ae_proc201.c ae_proc202.c ae_proc102.c ae_proc112.c ae_proc111.c ae_proc5_pt2a1.c ae_proc101.c ae_proc.c
  group AE-stu-inactive
    ./src/: ae_proc1.c ae_proc3.c ae_proc2.c ae_proc4.c
  group AE-obj-inactive
    ./AE-obj/: ae_proc112.o ae_proc111.o
target CS RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: as above
  output: CS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: K_MSG_ENV DEBUG_0 AE_ENABLE
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
